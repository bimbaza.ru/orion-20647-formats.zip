Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:13+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-UBD-GR-17
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-UBD-GR-17 Урна «Ротонда» · чёрный гранит
In: Площадка
Description: Изделие бетонное благоустройства. Урна «Ротонда» · чёрный гранит; Classification: 59.1.15.02-0567 Урна (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-UBD-GR-17; ModelReference: Урна «Ротонда» · чёрный гранит; ProductionYear: 2026; ArticleNumber: ZSK-UBD-GR-17
ORION_Изделие - Артикул: ZSK-UBD-GR-17; Артикул прежний: SD-UBD-GR-17; Наименование: Урна «Ротонда» · чёрный гранит; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 350×460×550 мм; Материал: Бетон; Цена: 32 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20647; Код КСИ: CPr>EDD250; Класс КСИ: Урна; Коды КСР: 59.1.15.02-0567 … 59.1.15.02-0579
ADSK - ADSK_Наименование: Урна «Ротонда» · чёрный гранит; ADSK_Марка: ZSK-UBD-GR-17; ADSK_Код изделия: 59.1.15.02-0567; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20647
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD250; ZSK_Артикул_прежний: SD-UBD-GR-17
Qto_ORION - Длина: 350 mm; Ширина: 460 mm; Высота: 550 mm
